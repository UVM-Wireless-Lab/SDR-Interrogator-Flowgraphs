options:
  parameters:
    author: Rye Fought (ryesof@gmail.com)
    description: Script for sweeping C/SB ratio for AM interrogation of harmonic transponder
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: CSB Gain Sweep
  states: {}

blocks:
- name: Average
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:(1,0,1,2)
    label: Averaging
    type: int
    value: '2'
  states: {}
- name: Decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: FRx
  id: variable
  parameters:
    value: 2*FTx-RxShift
  states: {}
- name: FTx
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:(0,0,1,2)
    label: Tx Freq
    type: real
    value: 890e6
  states: {}
- name: Fm
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: GRx
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:(0,2,1,2)
    label: Rx Gain
    type: real
    value: '35'
  states: {}
- name: GTx
  id: variable_qtgui_entry
  parameters:
    gui_hint: (1,1,1,1)
    label: Transmit Gain
    type: real
    value: '0'
  states: {}
- name: Length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Mod_ind
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:(0,4,1,2)
    label: Mod Index (0-1)
    type: real
    value: '0.5'
  states: {}
- name: RxShift
  id: variable
  parameters:
    value: 0.2e6
  states: {}
- name: Start
  id: variable_qtgui_label
  parameters:
    gui_hint: tab@0:(0,6,1,2)
    label: 'Starting Gain:  '
    type: real
    value: '0'
  states: {}
- name: Step
  id: variable_qtgui_label
  parameters:
    gui_hint: tab@0:(2,6,1,2)
    label: 'Step: '
    type: real
    value: '0.5'
  states: {}
- name: Stop
  id: variable_qtgui_label
  parameters:
    gui_hint: tab@0:(1,6,1,2)
    label: 'Final Gain: '
    type: real
    value: '70'
  states: {}
- name: Sweep
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: (1,0,1,1)
    label: 'Start Sweep:'
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: appendDT
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: tab@0:(1,4,1,2)
    label: 'Include Date/Time:'
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: buffer
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:(1,2,1,2)
    label: Buffers to discard
    type: int
    value: '10'
  states: {}
- name: lpf_cut
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: name
  id: variable_qtgui_entry
  parameters:
    gui_hint: (0,0,1,4)
    label: File Name
    type: string
    value: '""'
  states: {}
- name: outlen
  id: variable_qtgui_label
  parameters:
    gui_hint: tab@0:(3,6,1,2)
    label: 'Output Length: '
    type: int
    value: int(1+(Stop-Start)/Step)
  states: {}
- name: path
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:(2,1,1,4)
    label: File Path
    type: string
    value: /home/interrogator/Desktop/Data/CSB_Sweep/
  states: {}
- name: samp_rate_src
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: 0.5*Mod_ind
    freq: Fm
    offset: '0.5'
    phase: '0'
    samp_rate: samp_rate_src
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: Length
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-1*(RxShift)'
    sample_rate: samp_rate_src
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: GTx
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/Length
    type: complex
    vlen: Length
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: Length
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Length
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: Length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(Length)
  states: {}
- name: getPow
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      import numpy as np

      def nextPow(arg):
          return(int(2**np.ceil(np.log2(arg))))
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: Decimation
    gain: '1'
    samp_rate: samp_rate_src
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: portable_interrogator_blocks_CSB_calc_0
  id: portable_interrogator_blocks_CSB_calc
  parameters: {}
  states: {}
- name: portable_interrogator_blocks_csb_gain_control_0
  id: portable_interrogator_blocks_csb_gain_control
  parameters:
    Average: Average
    FileName: name
    OutLen: getPow.nextPow(outlen)
    Prefix: path
    Start: Start
    Step: Step
    Stop: Stop
    Sweep: Sweep
    appendDT: appendDT
    freq: FTx
    sample_buffer: buffer
  states: {}
- name: portable_interrogator_blocks_get_peaks_0
  id: portable_interrogator_blocks_get_peaks
  parameters:
    f1_ind: int((-1*Fm)*Length/(samp_rate_src/Decimation))+int(Length/2)
    f2_ind: int(Length/2)
    f3_ind: int((Fm)*Length/(samp_rate_src/Decimation))+int(Length/2)
    inVecSize: '1024'
    searchSize: '80'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_src/Decimation
    fc: FRx+RxShift
    fftsize: '1024'
    gui_hint: tab@1
    label1: Source 1
    name: '"FFT"'
    showports: 'True'
    type: complex
    width1: '4'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: (1,3,1,1)
    label1: C/SB
    type: float
    unit1: dB
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: tab@2
    legend: 'False'
    name: '"C/SB vs Relative Tx Power"'
    update_time: '0.01'
    vlen: getPow.nextPow(outlen)
    width1: '4'
    x_axis_label: '"Tx Gain [dB]"'
    x_start: Start
    x_step: Step
    x_units: '"dB"'
    y_axis_label: '"C/SB [dB]"'
    y_units: '"dB"'
    ymax: '20'
    ymin: '-1'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: (2,0,1,4)
    label0: Configuration
    label1: Rx Signal
    label2: Sweep Plot
    num_tabs: '3'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: FTx
    center_freq1: FTx
    gain0: GTx
    gain1: '0'
    nchan: '2'
    samp_rate: samp_rate_src
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: uhd.tune_request(FRx,0)
    center_freq1: uhd.tune_request(FRx,0)
    gain0: GRx
    gain1: GRx
    nchan: '2'
    rx_agc0: Disabled
    rx_agc1: Disabled
    samp_rate: samp_rate_src
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: In_LogMag
  states: {}
- name: virtual_sink_1_0_1
  id: virtual_sink
  parameters:
    stream_id: Input_0
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: In_LogMag
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Input_0
  states: {}

connections:
- [analog_sig_source_x_0_2, '0', blocks_float_to_complex_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_float_to_complex_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_nlog10_ff_0, '0', virtual_sink_0, '0']
- [blocks_null_source_0, '0', uhd_usrp_sink_0, '1']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', virtual_sink_1_0_1, '0']
- [portable_interrogator_blocks_CSB_calc_0, '0', portable_interrogator_blocks_csb_gain_control_0, '0']
- [portable_interrogator_blocks_CSB_calc_0, '0', qtgui_number_sink_0, '0']
- [portable_interrogator_blocks_CSB_calc_0, '1', portable_interrogator_blocks_csb_gain_control_0, '1']
- [portable_interrogator_blocks_CSB_calc_0, '2', portable_interrogator_blocks_csb_gain_control_0, '2']
- [portable_interrogator_blocks_CSB_calc_0, '3', portable_interrogator_blocks_csb_gain_control_0, '3']
- [portable_interrogator_blocks_csb_gain_control_0, '0', qtgui_vector_sink_f_0, '0']
- [portable_interrogator_blocks_csb_gain_control_0, gain_out, blocks_msgpair_to_var_0, inpair]
- [portable_interrogator_blocks_get_peaks_0, '0', portable_interrogator_blocks_CSB_calc_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0, '0']
- [uhd_usrp_source_0, '1', blocks_null_sink_0, '0']
- [virtual_source_0, '0', portable_interrogator_blocks_get_peaks_0, '0']
- [virtual_source_1, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
